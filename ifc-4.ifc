Properties of the parts of a building model (IFC4)

# File
Description: Universalkapillarthermostat, 20…150 °C, Hysterese 9,1 K, TR, Außeneinstellung, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: KA000002, Universalkapillarthermostat, 20…150 °C, Hysterese 9,1 K, TR, Außeneinstellung
In: Raum
Description: Diese Gerätereihe wurde speziell entwickelt für den Einsatz in der Heiztechnik in Kesselanlagen oder Speichern, Fernwärmeübergabestationen und Wärmeübertragungsanlagen, in der Lüftungstechnik als Zuluftüberwachung oder als Begrenzer von elektrischen Heizregistern sowie zur Regelung und Überwachung von Temperaturen an Rohrleitungen und Behältern. Tauchhülsen, Schutzwendel und Befestigungsset gehören nicht zum Lieferumfang. In Verbindung mit Tauchhülsen oder Schutzwendeln ist das Befestigungsset JZ-29 zu verwenden. Bei Verwendung als Anlegeregler (Rohrmontage) ist das Befestigungsset JZ-31 zu verwenden.; Classification: EC011173 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: KA000002; ModelLabel: RTKSA-000.300; GlobalTradeItemNumber: 4050528074638; ProductURL: https://alre.de/produkt_KA000002
Pset_Specification - NominalLength: 0.1468 m; NominalWidth: 0.0667 m; NominalDepth: 0.053 m; NetWeight: 0.251
Pset_ALRE_ETIM_Properties - Breite: 53; Höhe: 146.8; Tiefe: 66.7; Messbereich: 20; Explosionsgeschützt: no; Schutzart (IP): IP40; Ausführung Aufnehmer/Fühler: kapillar; Max. Mediumtemperatur (Dauerbetrieb): 177; Max. Spannung der Kontakte: 230; Kontaktverriegelung: no; Max. Kontaktbelastung: 16; Differenzwert: 9.1; Differenz verstellbar: no; ETIM-Klasse: EC011173; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-KA000002.pdf
